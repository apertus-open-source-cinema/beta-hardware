# Repository apertus-open-source-cinema/beta-hardware (continued)

## EAGLE design PCBs/axiom_beta_main_board_v0.36_r1.2/axiom_beta_main_board_v0.36_r1.2.brd (continued)

Schematic: axiom_beta_main_board_v0.37_r1.2.sch, sheet 2

Parts:
ZED1: µZ-FCI-NOHOLES-R; µZ-NOHOLES-R

Connections:
BANK13_00_N: ZED1.89 (_N); also elsewhere on the board
BANK13_00_P: ZED1.87 (_P); also elsewhere on the board
BANK13_01_N: ZED1.90 (_N); also elsewhere on the board
BANK13_01_P: ZED1.88 (_P); also elsewhere on the board
BANK13_02_N: ZED1.93 (_N); also elsewhere on the board
BANK13_02_P: ZED1.91 (_P); also elsewhere on the board
BANK13_03_N: ZED1.94 (_N); also elsewhere on the board
BANK13_03_P: ZED1.92 (_P); also elsewhere on the board
BANK13_04_N: ZED1.195 (_N); also elsewhere on the board
BANK13_04_P: ZED1.193 (_P); also elsewhere on the board
BANK13_05_N: ZED1.196 (_N); also elsewhere on the board
BANK13_05_P: ZED1.194 (_P); also elsewhere on the board
BANK13_06_N: ZED1.199 (_N); also elsewhere on the board
BANK13_06_P: ZED1.197 (_P); also elsewhere on the board
JX1_00_N: ZED1.13 (_N); also elsewhere on the board
JX1_00_P: ZED1.11 (_P); also elsewhere on the board
JX1_01_N: ZED1.14 (_N); also elsewhere on the board
JX1_01_P: ZED1.12 (_P); also elsewhere on the board
JX1_02_N: ZED1.19 (_N); also elsewhere on the board
JX1_02_P: ZED1.17 (_P); also elsewhere on the board
JX1_03_N: ZED1.20 (_N); also elsewhere on the board
JX1_03_P: ZED1.18 (_P); also elsewhere on the board
JX1_04_N: ZED1.25 (_N); also elsewhere on the board
JX1_04_P: ZED1.23 (_P); also elsewhere on the board
JX1_05_N: ZED1.26 (_N); also elsewhere on the board
JX1_05_P: ZED1.24 (_P); also elsewhere on the board
JX1_06_N: ZED1.31 (_N); also elsewhere on the board
JX1_06_P: ZED1.29 (_P); also elsewhere on the board
JX1_07_N: ZED1.32 (_N); also elsewhere on the board
JX1_07_P: ZED1.30 (_P); also elsewhere on the board
JX1_08_N: ZED1.37 (_N); also elsewhere on the board
JX1_08_P: ZED1.35 (_P); also elsewhere on the board
JX1_09_N: ZED1.38 (_N); also elsewhere on the board
JX1_09_P: ZED1.36 (_P); also elsewhere on the board
JX1_10_N: ZED1.43 (_N); also elsewhere on the board
JX1_10_P: ZED1.41 (_P); also elsewhere on the board
JX1_11_N: ZED1.44 (_N); also elsewhere on the board
JX1_11_P: ZED1.42 (_P); also elsewhere on the board
JX1_12_N: ZED1.49 (_N); also elsewhere on the board
JX1_12_P: ZED1.47 (_P); also elsewhere on the board
JX1_13_N: ZED1.50 (_N); also elsewhere on the board
JX1_13_P: ZED1.48 (_P); also elsewhere on the board
JX1_14_N: ZED1.55 (_N); also elsewhere on the board
JX1_14_P: ZED1.53 (_P); also elsewhere on the board
JX1_15_N: ZED1.56 (_N); also elsewhere on the board
JX1_15_P: ZED1.54 (_P); also elsewhere on the board
JX1_16_N: ZED1.63 (_N); also elsewhere on the board
JX1_16_P: ZED1.61 (_P); also elsewhere on the board
JX1_17_N: ZED1.64 (_N); also elsewhere on the board
JX1_17_P: ZED1.62 (_P); also elsewhere on the board
JX1_18_N: ZED1.69 (_N); also elsewhere on the board
JX1_18_P: ZED1.67 (_P); also elsewhere on the board
JX1_19_N: ZED1.70 (_N); also elsewhere on the board
JX1_19_P: ZED1.68 (_P); also elsewhere on the board
JX1_20_N: ZED1.75 (_N); also elsewhere on the board
JX1_20_P: ZED1.73 (_P); also elsewhere on the board
JX1_21_N: ZED1.76 (_N); also elsewhere on the board
JX1_21_P: ZED1.74 (_P); also elsewhere on the board
JX1_22_N: ZED1.83 (_N); also elsewhere on the board
JX1_22_P: ZED1.81 (_P); also elsewhere on the board
JX1_23_N: ZED1.84 (_N); also elsewhere on the board
JX1_23_P: ZED1.82 (_P); also elsewhere on the board
JX2_00_N: ZED1.119 (_N); also elsewhere on the board
JX2_00_P: ZED1.117 (_P); also elsewhere on the board
JX2_01_N: ZED1.120 (_N); also elsewhere on the board
JX2_01_P: ZED1.118 (_P); also elsewhere on the board
JX2_02_N: ZED1.125 (_N); also elsewhere on the board
JX2_02_P: ZED1.123 (_P); also elsewhere on the board
JX2_03_N: ZED1.126 (_N); also elsewhere on the board
JX2_03_P: ZED1.124 (_P); also elsewhere on the board
JX2_04_N: ZED1.131 (_N); also elsewhere on the board
JX2_04_P: ZED1.129 (_P); also elsewhere on the board
JX2_05_N: ZED1.132 (_N); also elsewhere on the board
JX2_05_P: ZED1.130 (_P); also elsewhere on the board
JX2_06_N: ZED1.137 (_N); also elsewhere on the board
JX2_06_P: ZED1.135 (_P); also elsewhere on the board
JX2_07_N: ZED1.138 (_N); also elsewhere on the board
JX2_07_P: ZED1.136 (_P); also elsewhere on the board
JX2_08_N: ZED1.143 (_N); also elsewhere on the board
JX2_08_P: ZED1.141 (_P); also elsewhere on the board
JX2_09_N: ZED1.144 (_N); also elsewhere on the board
JX2_09_P: ZED1.142 (_P); also elsewhere on the board
JX2_10_N: ZED1.149 (_N); also elsewhere on the board
JX2_10_P: ZED1.147 (_P); also elsewhere on the board
JX2_11_N: ZED1.150 (_N); also elsewhere on the board
JX2_11_P: ZED1.148 (_P); also elsewhere on the board
JX2_12_N: ZED1.155 (_N); also elsewhere on the board
JX2_12_P: ZED1.153 (_P); also elsewhere on the board
JX2_13_N: ZED1.156 (_N); also elsewhere on the board
JX2_13_P: ZED1.154 (_P); also elsewhere on the board
JX2_14_N: ZED1.163 (_N); also elsewhere on the board
JX2_14_P: ZED1.161 (_P); also elsewhere on the board
JX2_15_N: ZED1.164 (_N); also elsewhere on the board
JX2_15_P: ZED1.162 (_P); also elsewhere on the board
JX2_16_N: ZED1.169 (_N); also elsewhere on the board
JX2_16_P: ZED1.167 (_P); also elsewhere on the board
JX2_17_N: ZED1.170 (_N); also elsewhere on the board
JX2_17_P: ZED1.168 (_P); also elsewhere on the board
JX2_18_N: ZED1.175 (_N); also elsewhere on the board
JX2_18_P: ZED1.173 (_P); also elsewhere on the board
JX2_19_N: ZED1.176 (_N); also elsewhere on the board
JX2_19_P: ZED1.174 (_P); also elsewhere on the board
JX2_20_N: ZED1.183 (_N); also elsewhere on the board
JX2_20_P: ZED1.181 (_P); also elsewhere on the board
JX2_21_N: ZED1.184 (_N); also elsewhere on the board
JX2_21_P: ZED1.182 (_P); also elsewhere on the board
JX2_22_N: ZED1.189 (_N); also elsewhere on the board
JX2_22_P: ZED1.187 (_P); also elsewhere on the board
JX2_23_N: ZED1.190 (_N); also elsewhere on the board
JX2_23_P: ZED1.188 (_P); also elsewhere on the board

Notes on the sheet:
AXIOM Beta Main Board
Copyright (C) 2014-2020 H.Poetzl Licensed under CERN OHL v.1.2
ZYNQ LVDS Interface

Schematic: axiom_beta_main_board_v0.37_r1.2.sch, sheet 3

Parts:
X-EAST: FX10-100/10S; FX10A-100S/10
X-WEST: FX10-100/10S; FX10A-100S/10

Connections:
!E_RESET!: X-EAST.19; also elsewhere on the board
!W_RESET!: X-WEST.19; also elsewhere on the board
E_EN: X-EAST.14; also elsewhere on the board
E_I2C_EN: X-EAST.13; also elsewhere on the board
E_I2C_V: X-EAST.11; also elsewhere on the board
E_SCK: X-EAST.12; also elsewhere on the board
E_SCL: X-EAST.15; also elsewhere on the board
E_SDA: X-EAST.17; also elsewhere on the board
E_SDI: X-EAST.16; also elsewhere on the board
E_SDO: X-EAST.18; also elsewhere on the board
E_SPI_V: X-EAST.21; also elsewhere on the board
E_VE_CV: X-EAST.90; also elsewhere on the board
E_VE_OV: X-EAST.93; also elsewhere on the board
E_VE_UV: X-EAST.91; also elsewhere on the board
GND: X-EAST.5, X-EAST.20, X-EAST.23, X-EAST.26, X-EAST.29, X-EAST.31, X-EAST.32, X-EAST.37, X-EAST.38, X-EAST.43, X-EAST.44, X-EAST.49, X-EAST.50, X-EAST.51, X-EAST.52, X-EAST.57, X-EAST.58, X-EAST.63, X-EAST.64, X-EAST.69, X-EAST.70, X-EAST.71, X-EAST.76, X-EAST.77, X-EAST.82, X-EAST.G1, X-EAST.G2, X-EAST.G3, X-EAST.G4, X-EAST.G5, X-EAST.G6, X-EAST.G7, X-EAST.G8, X-EAST.G9, X-EAST.G10, X-WEST.5, X-WEST.20, X-WEST.23, X-WEST.26, X-WEST.29, X-WEST.31, X-WEST.32, X-WEST.37, X-WEST.38, X-WEST.43, X-WEST.44, X-WEST.49, X-WEST.50, X-WEST.51, X-WEST.52, X-WEST.57, X-WEST.58, X-WEST.63, X-WEST.64, X-WEST.69, X-WEST.70, X-WEST.71, X-WEST.76, X-WEST.77, X-WEST.82, X-WEST.G1, X-WEST.G2, X-WEST.G3, X-WEST.G4, X-WEST.G5, X-WEST.G6, X-WEST.G7, X-WEST.G8, X-WEST.G9, X-WEST.G10; also elsewhere on the board
JTAG_V: X-WEST.21; also elsewhere on the board
JX1_00_N: X-EAST.27; also elsewhere on the board
JX1_00_P: X-EAST.25; also elsewhere on the board
JX1_02_N: X-EAST.24; also elsewhere on the board
JX1_02_P: X-EAST.22; also elsewhere on the board
JX1_04_N: X-EAST.30; also elsewhere on the board
JX1_04_P: X-EAST.28; also elsewhere on the board
JX1_06_N: X-EAST.36; also elsewhere on the board
JX1_06_P: X-EAST.34; also elsewhere on the board
JX1_07_N: X-EAST.35; also elsewhere on the board
JX1_07_P: X-EAST.33; also elsewhere on the board
JX1_08_N: X-EAST.42; also elsewhere on the board
JX1_08_P: X-EAST.40; also elsewhere on the board
JX1_09_N: X-EAST.41; also elsewhere on the board
JX1_09_P: X-EAST.39; also elsewhere on the board
JX1_10_N: X-EAST.48; also elsewhere on the board
JX1_10_P: X-EAST.46; also elsewhere on the board
JX1_11_N: X-EAST.47; also elsewhere on the board
JX1_11_P: X-EAST.45; also elsewhere on the board
JX1_12_N: X-WEST.56; also elsewhere on the board
JX1_12_P: X-WEST.54; also elsewhere on the board
JX1_13_N: X-WEST.55; also elsewhere on the board
JX1_13_P: X-WEST.53; also elsewhere on the board
JX1_14_N: X-WEST.62; also elsewhere on the board
JX1_14_P: X-WEST.60; also elsewhere on the board
JX1_15_N: X-WEST.61; also elsewhere on the board
JX1_15_P: X-WEST.59; also elsewhere on the board
JX1_16_N: X-WEST.68; also elsewhere on the board
JX1_16_P: X-WEST.66; also elsewhere on the board
JX1_17_N: X-WEST.67; also elsewhere on the board
JX1_17_P: X-WEST.65; also elsewhere on the board
JX1_18_N: X-WEST.74; also elsewhere on the board
JX1_18_P: X-WEST.72; also elsewhere on the board
JX1_20_N: X-WEST.80; also elsewhere on the board
JX1_20_P: X-WEST.78; also elsewhere on the board
JX1_22_N: X-WEST.75; also elsewhere on the board
JX1_22_P: X-WEST.73; also elsewhere on the board
JX2_01_N: X-EAST.73; also elsewhere on the board
JX2_01_P: X-EAST.75; also elsewhere on the board
JX2_03_N: X-EAST.78; also elsewhere on the board
JX2_03_P: X-EAST.80; also elsewhere on the board
JX2_05_N: X-EAST.72; also elsewhere on the board
JX2_05_P: X-EAST.74; also elsewhere on the board
JX2_06_N: X-EAST.65; also elsewhere on the board
JX2_06_P: X-EAST.67; also elsewhere on the board
JX2_07_N: X-EAST.66; also elsewhere on the board
JX2_07_P: X-EAST.68; also elsewhere on the board
JX2_08_N: X-EAST.59; also elsewhere on the board
JX2_08_P: X-EAST.61; also elsewhere on the board
JX2_09_N: X-EAST.60; also elsewhere on the board
JX2_09_P: X-EAST.62; also elsewhere on the board
JX2_10_N: X-EAST.53; also elsewhere on the board
JX2_10_P: X-EAST.55; also elsewhere on the board
JX2_11_N: X-EAST.54; also elsewhere on the board
JX2_11_P: X-EAST.56; also elsewhere on the board
JX2_12_N: X-WEST.45; also elsewhere on the board
JX2_12_P: X-WEST.47; also elsewhere on the board
JX2_13_N: X-WEST.46; also elsewhere on the board
JX2_13_P: X-WEST.48; also elsewhere on the board
JX2_14_N: X-WEST.39; also elsewhere on the board
JX2_14_P: X-WEST.41; also elsewhere on the board
JX2_15_N: X-WEST.40; also elsewhere on the board
JX2_15_P: X-WEST.42; also elsewhere on the board
JX2_16_N: X-WEST.33; also elsewhere on the board
JX2_16_P: X-WEST.35; also elsewhere on the board
JX2_17_N: X-WEST.34; also elsewhere on the board
JX2_17_P: X-WEST.36; also elsewhere on the board
JX2_19_N: X-WEST.28; also elsewhere on the board
JX2_19_P: X-WEST.30; also elsewhere on the board
JX2_21_N: X-WEST.22; also elsewhere on the board
JX2_21_P: X-WEST.24; also elsewhere on the board
JX2_23_N: X-WEST.25; also elsewhere on the board
JX2_23_P: X-WEST.27; also elsewhere on the board
N_CHK_EN: X-WEST.94
N_CHK_V: X-WEST.92; also elsewhere on the board
N_I2C_EN: X-EAST.7; also elsewhere on the board
N_I2C_V: X-EAST.9; also elsewhere on the board
N_SCK: X-EAST.2; also elsewhere on the board
N_SCL: X-EAST.1; also elsewhere on the board
N_SDA: X-EAST.3; also elsewhere on the board
N_SDI: X-EAST.6; also elsewhere on the board
N_SDO: X-EAST.4; also elsewhere on the board
N_SPI_EN: X-EAST.8; also elsewhere on the board
N_SPI_V: X-EAST.10; also elsewhere on the board
N_VE_CV: X-WEST.96; also elsewhere on the board
N_VE_OV: X-WEST.95; also elsewhere on the board
N_VE_RS: X-WEST.88; also elsewhere on the board
N_VE_UV: X-WEST.85; also elsewhere on the board
N_VN_CV: X-WEST.98; also elsewhere on the board
N_VN_OV: X-WEST.97; also elsewhere on the board
N_VN_RS: X-WEST.86; also elsewhere on the board
N_VN_UV: X-WEST.87; also elsewhere on the board
N_VW_CV: X-WEST.100; also elsewhere on the board
N_VW_OV: X-WEST.99; also elsewhere on the board
N_VW_RS: X-WEST.84; also elsewhere on the board
N_VW_UV: X-WEST.89; also elsewhere on the board
RES1: X-WEST.79
RES2: X-WEST.81
RES3: X-WEST.83
RES4: X-EAST.79
RES5: X-EAST.81
RES6: X-EAST.83
S_CHK_EN: X-EAST.94
S_CHK_V: X-EAST.92; also elsewhere on the board
S_I2C_EN: X-WEST.7; also elsewhere on the board
S_I2C_V: X-WEST.9; also elsewhere on the board
S_SCK: X-WEST.2; also elsewhere on the board
S_SCL: X-WEST.1; also elsewhere on the board
S_SDA: X-WEST.3; also elsewhere on the board
S_SDI: X-WEST.6; also elsewhere on the board
S_SDO: X-WEST.4; also elsewhere on the board
S_SPI_EN: X-WEST.8; also elsewhere on the board
S_SPI_V: X-WEST.10; also elsewhere on the board
S_VE_CV: X-EAST.100; also elsewhere on the board
S_VE_OV: X-EAST.99; also elsewhere on the board
S_VE_RS: X-EAST.84; also elsewhere on the board
S_VE_UV: X-EAST.89; also elsewhere on the board
S_VS_CV: X-EAST.98; also elsewhere on the board
S_VS_OV: X-EAST.97; also elsewhere on the board
S_VS_RS: X-EAST.86; also elsewhere on the board
S_VS_UV: X-EAST.87; also elsewhere on the board
S_VW_CV: X-EAST.96; also elsewhere on the board
S_VW_OV: X-EAST.95; also elsewhere on the board
S_VW_RS: X-EAST.88; also elsewhere on the board
S_VW_UV: X-EAST.85; also elsewhere on the board
TCK: X-WEST.12; also elsewhere on the board
TDI: X-WEST.16; also elsewhere on the board
TDO: X-WEST.18; also elsewhere on the board
TMS: X-WEST.14; also elsewhere on the board
W_I2C_EN: X-WEST.13; also elsewhere on the board
W_I2C_V: X-WEST.11; also elsewhere on the board
W_SCL: X-WEST.15; also elsewhere on the board
W_SDA: X-WEST.17; also elsewhere on the board
W_VW_CV: X-WEST.90; also elsewhere on the board
W_VW_OV: X-WEST.93; also elsewhere on the board
W_VW_UV: X-WEST.91; also elsewhere on the board

Notes on the sheet:
AXIOM Beta Main Board
Copyright (C) 2014-2020 H.Poetzl Licensed under CERN OHL v.1.2
Interface Board Connection

Schematic: axiom_beta_main_board_v0.37_r1.2.sch, sheet 4

Parts:
C1, C1', C3, C3', C5, C5', C7, C7': C0805-A; 0805-A
C2, C2', C4, C4', C6, C6', C8, C8': C0603-A; 0603-A
PAD1, PAD2, PAD3, PAD4, PAD5, PAD6, PAD7, PAD8, PAD9, PAD10, PAD11, PAD12, PAD13, PAD14, PAD15, PAD16: PINPAD1.27MM; 1.2/0.6
PB-NW: DF12(XX)-20DP-0.5V
PB-SE: DF12(XX)-20DP-0.5V
PCIE-NORTH: PCIE-36-AXIOM-NOPEG; PCIE-36-NOPEG
PCIE-SOUTH: PCIE-36-AXIOM-NOPEG; PCIE-36-NOPEG
PWR-NE: PINHD-2X02_2.54; 2X02
PWR-NW: PINHD-2X02_2.54; 2X02
PWR-SE: PINHD-2X02_2.54; 2X02
PWR-SW: PINHD-2X02_2.54; 2X02
R1, R2, R3, R4, R5, R6: 4k7; 0402-B
U1: PCA9540BDP; SOP65P490X300-8N

Connections:
A_!RST: PB-NW.2; also elsewhere on the board
A_SCL: PB-NW.1; also elsewhere on the board
A_SDA: PB-NW.3; also elsewhere on the board
BANK13_00_N: PCIE-NORTH.B17 (LVDS_5B); also elsewhere on the board
BANK13_00_P: PCIE-NORTH.B16 (LVDS_5A); also elsewhere on the board
BANK13_02_N: PCIE-NORTH.A16 (LVDS_4A); also elsewhere on the board
BANK13_02_P: PCIE-NORTH.A17 (LVDS_4B); also elsewhere on the board
BANK13_03_N: PCIE-NORTH.A14 (LVDS_3B); also elsewhere on the board
BANK13_03_P: PCIE-NORTH.A13 (LVDS_3A); also elsewhere on the board
BANK13_04_N: PCIE-SOUTH.A6 (LVDS_1B); also elsewhere on the board
BANK13_04_P: PCIE-SOUTH.A5 (LVDS_1A); also elsewhere on the board
BANK13_05_N: PCIE-SOUTH.A3 (LVDS_0B); also elsewhere on the board
BANK13_05_P: PCIE-SOUTH.A2 (LVDS_0A); also elsewhere on the board
BANK13_06_N: PCIE-SOUTH.A8 (LVDS_2A); also elsewhere on the board
BANK13_06_P: PCIE-SOUTH.A9 (LVDS_2B); also elsewhere on the board
B_!RST: PB-SE.2; also elsewhere on the board
B_SCL: PB-SE.1; also elsewhere on the board
B_SDA: PB-SE.3; also elsewhere on the board
CSO_NE_V: C3.1, C3'.1, C4.1, C4'.1, PAD2.1; also elsewhere on the board
CSO_NW_V: C1.1, C1'.1, C2.1, C2'.1, PAD15.1, PWR-NW.1
CSO_SE_V: C7.1, C7'.1, C8.1, C8'.1, PAD7.1, PWR-SE.1
CSO_SW_V: C5.1, C5'.1, C6.1, C6'.1, PAD10.1; also elsewhere on the board
C_CK_E: PAD5.1; also elsewhere on the board
C_CK_W: PAD13.1; also elsewhere on the board
C_EN_E: PAD3.1; also elsewhere on the board
C_EN_W: PAD11.1; also elsewhere on the board
C_SI_E: PAD4.1; also elsewhere on the board
C_SI_W: PAD12.1; also elsewhere on the board
C_SO_E: PAD6.1; also elsewhere on the board
C_SO_W: PAD14.1; also elsewhere on the board
E_I2C_V: PWR-NE.1; also elsewhere on the board
E_SPI_V: PWR-NE.3; also elsewhere on the board
E_VE_CV: PB-SE.19; also elsewhere on the board
E_VE_OV: PB-SE.10; also elsewhere on the board
E_VE_UV: PB-SE.12; also elsewhere on the board
GND: C1.2, C1'.2, C2.2, C2'.2, C3.2, C3'.2, C4.2, C4'.2, C5.2, C5'.2, C6.2, C6'.2, C7.2, C7'.2, C8.2, C8'.2, PAD1.1, PAD8.1, PAD9.1, PAD16.1, PB-NW.5, PB-SE.5, PCIE-NORTH.A1 (GND), PCIE-NORTH.A4 (GND), PCIE-NORTH.A7 (GND), PCIE-NORTH.A10 (GND), PCIE-NORTH.A12 (GND), PCIE-NORTH.A15 (GND), PCIE-NORTH.A18 (GND), PCIE-NORTH.B15 (GND), PCIE-NORTH.B18 (GND), PCIE-SOUTH.A1 (GND), PCIE-SOUTH.A4 (GND), PCIE-SOUTH.A7 (GND), PCIE-SOUTH.A10 (GND), PCIE-SOUTH.A12 (GND), PCIE-SOUTH.A15 (GND), PCIE-SOUTH.A18 (GND), PCIE-SOUTH.B15 (GND), PCIE-SOUTH.B18 (GND), U1.6 (VSS); also elsewhere on the board
JTAG_V: PWR-SW.3; also elsewhere on the board
JX1_19_N: PCIE-NORTH.A3 (LVDS_0B); also elsewhere on the board
JX1_19_P: PCIE-NORTH.A2 (LVDS_0A); also elsewhere on the board
JX1_21_N: PCIE-NORTH.A6 (LVDS_1B); also elsewhere on the board
JX1_21_P: PCIE-NORTH.A5 (LVDS_1A); also elsewhere on the board
JX1_23_N: PCIE-NORTH.A9 (LVDS_2B); also elsewhere on the board
JX1_23_P: PCIE-NORTH.A8 (LVDS_2A); also elsewhere on the board
JX2_18_N: PCIE-SOUTH.B17 (LVDS_5B); also elsewhere on the board
JX2_18_P: PCIE-SOUTH.B16 (LVDS_5A); also elsewhere on the board
JX2_20_N: PCIE-SOUTH.A17 (LVDS_4B); also elsewhere on the board
JX2_20_P: PCIE-SOUTH.A16 (LVDS_4A); also elsewhere on the board
JX2_22_N: PCIE-SOUTH.A13 (LVDS_3A); also elsewhere on the board
JX2_22_P: PCIE-SOUTH.A14 (LVDS_3B); also elsewhere on the board
N_CHK_V: PB-NW.14; also elsewhere on the board
N_I2C_V: PWR-NE.4; also elsewhere on the board
N_SPI_V: PWR-NE.2; also elsewhere on the board
N_VE_CV: PB-NW.17; also elsewhere on the board
N_VE_OV: PB-NW.8; also elsewhere on the board
N_VE_RS: PB-NW.7; also elsewhere on the board
N_VE_UV: PB-NW.20; also elsewhere on the board
N_VN_CV: PB-NW.15; also elsewhere on the board
N_VN_OV: PB-NW.6; also elsewhere on the board
N_VN_RS: PB-NW.11; also elsewhere on the board
N_VN_UV: PB-NW.18; also elsewhere on the board
N_VW_CV: PB-NW.13; also elsewhere on the board
N_VW_OV: PB-NW.4; also elsewhere on the board
N_VW_RS: PB-NW.9; also elsewhere on the board
N_VW_UV: PB-NW.16; also elsewhere on the board
PCIE_I2C_V: PCIE-NORTH.B3 (V_I2C), PCIE-SOUTH.B3 (V_I2C), R3.1, R4.1, R5.1, R6.1, U1.3 (VDD); also elsewhere on the board
PCIE_N_5V: PCIE-NORTH.B12 (5V); also elsewhere on the board
PCIE_N_IO0: PCIE-NORTH.B4 (IO0); also elsewhere on the board
PCIE_N_IO1: PCIE-NORTH.B5 (IO1); also elsewhere on the board
PCIE_N_IO2: PCIE-NORTH.B6 (IO2); also elsewhere on the board
PCIE_N_IO3: PCIE-NORTH.B7 (IO3); also elsewhere on the board
PCIE_N_IO4: PCIE-NORTH.B8 (IO4); also elsewhere on the board
PCIE_N_IO5: PCIE-NORTH.B9 (IO5); also elsewhere on the board
PCIE_N_IO6: PCIE-NORTH.B10 (IO6); also elsewhere on the board
PCIE_N_IO7: PCIE-NORTH.B11 (IO7); also elsewhere on the board
PCIE_N_SCL: PCIE-NORTH.B2 (SCL), R4.2, U1.5 (SC0)
PCIE_N_SDA: PCIE-NORTH.B1 (SDA), R3.2, U1.4 (SD0)
PCIE_N_V: PCIE-NORTH.B13 (VCC); also elsewhere on the board
PCIE_N_VCCIO: PCIE-NORTH.B14 (VCCIO); also elsewhere on the board
PCIE_SCL: R2.2, U1.1 (SCL); also elsewhere on the board
PCIE_SDA: R1.2, U1.2 (SDA); also elsewhere on the board
PCIE_S_5V: PCIE-SOUTH.B12 (5V); also elsewhere on the board
PCIE_S_IO0: PCIE-SOUTH.B4 (IO0); also elsewhere on the board
PCIE_S_IO1: PCIE-SOUTH.B5 (IO1); also elsewhere on the board
PCIE_S_IO2: PCIE-SOUTH.B6 (IO2); also elsewhere on the board
PCIE_S_IO3: PCIE-SOUTH.B7 (IO3); also elsewhere on the board
PCIE_S_IO4: PCIE-SOUTH.B8 (IO4); also elsewhere on the board
PCIE_S_IO5: PCIE-SOUTH.B9 (IO5); also elsewhere on the board
PCIE_S_IO6: PCIE-SOUTH.B10 (IO6); also elsewhere on the board
PCIE_S_IO7: PCIE-SOUTH.B11 (IO7); also elsewhere on the board
PCIE_S_SCL: PCIE-SOUTH.B2 (SCL), R6.2, U1.8 (SC1)
PCIE_S_SDA: PCIE-SOUTH.B1 (SDA), R5.2, U1.7 (SD1)
PCIE_S_V: PCIE-SOUTH.B13 (VCC); also elsewhere on the board
PCIE_S_VCCIO: PCIE-SOUTH.B14 (VCCIO); also elsewhere on the board
RFAB_E_V: PWR-SE.3; also elsewhere on the board
RFAB_W_V: PWR-NW.3; also elsewhere on the board
SH_NW_V: PWR-NW.4; also elsewhere on the board
SH_NW_VIO: PWR-NW.2, R1.1, R2.1; also elsewhere on the board
SH_SE_V: PWR-SE.4; also elsewhere on the board
SH_SE_VIO: PWR-SE.2; also elsewhere on the board
S_CHK_V: PB-SE.14; also elsewhere on the board
S_I2C_V: PWR-SW.4; also elsewhere on the board
S_SPI_V: PWR-SW.2; also elsewhere on the board
S_VE_CV: PB-SE.13; also elsewhere on the board
S_VE_OV: PB-SE.4; also elsewhere on the board
S_VE_RS: PB-SE.9; also elsewhere on the board
S_VE_UV: PB-SE.16; also elsewhere on the board
S_VS_CV: PB-SE.15; also elsewhere on the board
S_VS_OV: PB-SE.6; also elsewhere on the board
S_VS_RS: PB-SE.11; also elsewhere on the board
S_VS_UV: PB-SE.18; also elsewhere on the board
S_VW_CV: PB-SE.17; also elsewhere on the board
S_VW_OV: PB-SE.8; also elsewhere on the board
S_VW_RS: PB-SE.7; also elsewhere on the board
S_VW_UV: PB-SE.20; also elsewhere on the board
W_I2C_V: PWR-SW.1; also elsewhere on the board
W_VW_CV: PB-NW.19; also elsewhere on the board
W_VW_OV: PB-NW.10; also elsewhere on the board
W_VW_UV: PB-NW.12; also elsewhere on the board

Notes on the sheet:
AXIOM Beta Main Board
Copyright (C) 2015-2020 H.Poetzl Licensed under CERN OHL v.1.2
PCIE, Power, Center Area

Schematic: axiom_beta_main_board_v0.37_r1.2.sch, sheet 5

Parts:
C9, C10, C11, C12, C13, C41: 100n; 0402-B
C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29: 10n; 0402-B
HDR-NW: PINHD-2X08_2.00_LPR; 62101621821
HDR-SW: PINHD-2X08_2.00_LPR; 62101621821
R7: 50R; 0402-B
R15: 100R; 0201-B
R18: 10k; 0402-B
RFW: MACHXO2-100; MACHXO2-100TQFP
U2: PIC16F1718-I/MV; QFN40P400X400X55-29N

Connections:
!SS!_W: RFW.27 (CSSPIN), U2.4 (RA5)
!W_RESET!: U2.1 (RA2); also elsewhere on the board
A_!RST: R18.2, U2.26 (RE3/!MCLR!/VPP); also elsewhere on the board
A_SCL: U2.24 (RB6/ICSPCLK); also elsewhere on the board
A_SDA: U2.25 (RB7/ICSPDAT); also elsewhere on the board
BANK13_01_N: R15.2, RFW.38 (PB11A); also elsewhere on the board
BANK13_01_P: R15.1, RFW.39 (PB11B); also elsewhere on the board
BANK13_SE_0: R7.1, RFW.88 (PT12A), U2.7 (RA6); also elsewhere on the board
C_CK_W: RFW.18 (PL8C); also elsewhere on the board
C_EN_W: RFW.14 (PL5C); also elsewhere on the board
C_SI_W: RFW.19 (PL8D); also elsewhere on the board
C_SO_W: RFW.15 (PL5D); also elsewhere on the board
DONE_W: RFW.76 (DONE), U2.20 (RB2)
GND: C9.2, C10.2, C11.2, C12.2, C13.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C41.2, HDR-SW.1, HDR-SW.2, R7.2, RFW.6 (GND), RFW.22 (GND), RFW.33 (GND), RFW.44 (GND), RFW.56 (GND), RFW.72 (GND), RFW.79 (GND), RFW.92 (GND), U2.5 (VSS), U2.16 (VSS), U2.29 (EPAD); also elsewhere on the board
INITN_W: RFW.77 (INITN), U2.18 (RB0)
JTAGENB_W: RFW.82 (JTAGENB), U2.14 (RC6)
PB22B_W: RFW.47 (PB18D), U2.23 (RB5)
PCIE_N_IO0: RFW.83 (PT15B); also elsewhere on the board
PCIE_N_IO1: RFW.78 (PT16C); also elsewhere on the board
PCIE_N_IO2: RFW.74 (PR2B); also elsewhere on the board
PCIE_N_IO3: RFW.75 (PR2A); also elsewhere on the board
PCIE_N_IO4: RFW.71 (PR3A); also elsewhere on the board
PCIE_N_IO5: RFW.70 (PR3B); also elsewhere on the board
PCIE_N_IO6: RFW.69 (PR4A); also elsewhere on the board
PCIE_N_IO7: RFW.68 (PR4B); also elsewhere on the board
PCIE_SCL: RFW.86 (SCL), U2.12 (RC4); also elsewhere on the board
PCIE_SDA: RFW.85 (SDA), U2.13 (RC5); also elsewhere on the board
PCIE_S_IO0: RFW.1 (PL2C); also elsewhere on the board
PCIE_S_IO1: RFW.2 (PL2D); also elsewhere on the board
PCIE_S_IO2: RFW.98 (PT9B); also elsewhere on the board
PCIE_S_IO3: RFW.99 (PT9A); also elsewhere on the board
PCIE_S_IO4: RFW.96 (PT10B); also elsewhere on the board
PCIE_S_IO5: RFW.97 (PT10A); also elsewhere on the board
PCIE_S_IO6: RFW.84 (PT15A); also elsewhere on the board
PCIE_S_IO7: RFW.87 (PT12B); also elsewhere on the board
PROGRAMN_W: RFW.81 (PROGRAMN), U2.15 (RC7)
RFAB_W_V: C9.1, C10.1, C19.1, C20.1, RFW.50 (VCC), RFW.100 (VCC); also elsewhere on the board
SCK_W: RFW.31 (MCLK), U2.3 (RA4)
SDI_W: RFW.49 (SI/SISPI), U2.21 (RB3)
SDO_W: RFW.32 (SO/SPISO), U2.2 (RA3)
SH_NW_IO0: HDR-NW.4, RFW.67 (PR4C)
SH_NW_IO1: HDR-NW.3, RFW.66 (PR4D)
SH_NW_IO2: HDR-NW.6, RFW.65 (PR5A)
SH_NW_IO3: HDR-NW.5, RFW.64 (PR5B)
SH_NW_IO4: HDR-NW.8, RFW.63 (PR5C)
SH_NW_IO5: HDR-NW.7, RFW.62 (PR5D)
SH_NW_IO6: HDR-NW.10, RFW.60 (PR8C)
SH_NW_IO7: HDR-NW.9, RFW.59 (PR8D)
SH_NW_IO8: HDR-NW.12, RFW.58 (PR9A)
SH_NW_IO9: HDR-NW.11, RFW.57 (PR9B)
SH_NW_V: HDR-NW.2; also elsewhere on the board
SH_NW_VIO: C11.1, C12.1, C13.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C41.1, HDR-NW.1, R18.1, RFW.5 (VCCIO5), RFW.11 (VCCIO4), RFW.23 (VCCIO3), RFW.26 (VCCIO2), RFW.46 (VCCIO2), RFW.55 (VCCIO1), RFW.73 (VCCIO1), RFW.80 (VCCIO0), RFW.93 (VCCIO0), U2.17 (VDD); also elsewhere on the board
SH_SW_IO0: HDR-SW.4, RFW.4 (PL3B)
SH_SW_IO1: HDR-SW.3, RFW.3 (PL3A)
SH_SW_IO2: HDR-SW.6, RFW.8 (PL3D)
SH_SW_IO3: HDR-SW.5, RFW.7 (PL3C)
SH_SW_IO4: HDR-SW.8, RFW.10 (PL4B)
SH_SW_IO5: HDR-SW.7, RFW.9 (PL4A)
SH_SW_IO6: HDR-SW.10, RFW.12 (PL5A)
SH_SW_IO7: HDR-SW.9, RFW.13 (PL5B)
SH_SW_IO8: HDR-SW.12, RFW.16 (PL8A)
SH_SW_IO9: HDR-SW.11, RFW.17 (PL8B)
SN_W: RFW.48 (SN), U2.22 (RB4)
S_I2C_EN: U2.28 (RA1); also elsewhere on the board
S_SCK: RFW.28 (PB4D); also elsewhere on the board
S_SCL: RFW.34 (PB9A); also elsewhere on the board
S_SDA: RFW.35 (PB9B); also elsewhere on the board
S_SDI: RFW.30 (PB6B); also elsewhere on the board
S_SDO: RFW.29 (PB6A); also elsewhere on the board
S_SPI_EN: RFW.45 (PB18C); also elsewhere on the board
TCK: RFW.43 (PB18B); also elsewhere on the board
TCK_W: RFW.91 (TCK), U2.10 (RC2)
TDI: RFW.41 (PB15B); also elsewhere on the board
TDI_W: RFW.94 (TDI), U2.9 (RC1)
TDO: RFW.40 (PB15A); also elsewhere on the board
TDO_W: RFW.95 (TDO), U2.8 (RC0)
TMS: RFW.42 (PB18A); also elsewhere on the board
TMS_W: RFW.90 (TMS), U2.11 (RC3)
W_I2C_EN: U2.27 (RA0); also elsewhere on the board
W_SCL: RFW.36 (PB11C); also elsewhere on the board
W_SDA: RFW.37 (PB11D); also elsewhere on the board
XX1_N: HDR-NW.13, RFW.52 (PR10C)
XX1_P: HDR-NW.15, RFW.51 (PR10D)
XX2_N: HDR-NW.14, RFW.54 (PR9C)
XX2_P: HDR-NW.16, RFW.53 (PR9D)
XX3_N: HDR-SW.16, RFW.25 (PL10D)
XX3_P: HDR-SW.14, RFW.24 (PL10C)
XX4_N: HDR-SW.15, RFW.21 (PL9B)
XX4_P: HDR-SW.13, RFW.20 (PL9A)

Notes on the sheet:
AXIOM Beta Main Board
Copyright (C) 2015-2020 H.Poetzl Licensed under CERN OHL v.1.2
Interface Fabric West

Schematic: axiom_beta_main_board_v0.37_r1.2.sch, sheet 6

Parts:
C14, C15, C16, C17, C18, C42: 100n; 0402-B
C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40: 10n; 0402-B
HDR-NE: PINHD-2X08_2.00_LPR; 62101621821
HDR-SE: PINHD-2X08_2.00_LPR; 62101621821
R8: 50R; 0402-B
R16, R17: 100R; 0201-B
R19: 10k; 0402-B
RFE: MACHXO2-100; MACHXO2-100TQFP
U3: PIC16F1718-I/MV; QFN40P400X400X55-29N

Connections:
!E_RESET!: U3.1 (RA2); also elsewhere on the board
!SS!_E: RFE.27 (CSSPIN), U3.4 (RA5)
B_!RST: R19.2, U3.26 (RE3/!MCLR!/VPP); also elsewhere on the board
B_SCL: U3.24 (RB6/ICSPCLK); also elsewhere on the board
B_SDA: U3.25 (RB7/ICSPDAT); also elsewhere on the board
C_CK_E: RFE.18 (PL8C); also elsewhere on the board
C_EN_E: RFE.14 (PL5C); also elsewhere on the board
C_SI_E: RFE.19 (PL8D); also elsewhere on the board
C_SO_E: RFE.15 (PL5D); also elsewhere on the board
DONE_E: RFE.76 (DONE), U3.20 (RB2)
E_EN: RFE.20 (PL9A); also elsewhere on the board
E_I2C_EN: U3.27 (RA0); also elsewhere on the board
E_IO0: RFE.99 (PT9A)
E_IO1: RFE.98 (PT9B)
E_IO2: RFE.97 (PT10A)
E_IO3: RFE.96 (PT10B)
E_IO5: RFE.87 (PT12B)
E_IO6: RFE.84 (PT15A)
E_IO7: RFE.83 (PT15B)
E_SCK: RFE.21 (PL9B); also elsewhere on the board
E_SCL: RFE.36 (PB11C); also elsewhere on the board
E_SDA: RFE.37 (PB11D); also elsewhere on the board
E_SDI: RFE.24 (PL10C); also elsewhere on the board
E_SDO: RFE.25 (PL10D); also elsewhere on the board
GND: C14.2, C15.2, C16.2, C17.2, C18.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C42.2, HDR-NE.1, HDR-NE.2, R8.2, RFE.6 (GND), RFE.22 (GND), RFE.33 (GND), RFE.44 (GND), RFE.56 (GND), RFE.72 (GND), RFE.79 (GND), RFE.92 (GND), U3.5 (VSS), U3.16 (VSS), U3.29 (EPAD); also elsewhere on the board
INITN_E: RFE.77 (INITN), U3.18 (RB0)
IO_SCL: RFE.86 (SCL), U3.12 (RC4)
IO_SDA: RFE.85 (SDA), U3.13 (RC5)
JTAGENB_E: RFE.82 (JTAGENB), U3.14 (RC6)
JX1_01_N: HDR-NE.13; also elsewhere on the board
JX1_01_P: HDR-NE.15; also elsewhere on the board
JX1_03_N: HDR-NE.14; also elsewhere on the board
JX1_03_P: HDR-NE.16; also elsewhere on the board
JX1_05_N: R16.2, RFE.35 (PB9B); also elsewhere on the board
JX1_05_P: R16.1, RFE.34 (PB9A); also elsewhere on the board
JX1_SE_0: R8.1, RFE.88 (PT12A), U3.7 (RA6); also elsewhere on the board
JX2_00_N: HDR-SE.14; also elsewhere on the board
JX2_00_P: HDR-SE.16; also elsewhere on the board
JX2_02_N: HDR-SE.13; also elsewhere on the board
JX2_02_P: HDR-SE.15; also elsewhere on the board
JX2_04_N: R17.1, RFE.38 (PB11A); also elsewhere on the board
JX2_04_P: R17.2, RFE.39 (PB11B); also elsewhere on the board
N_I2C_EN: U3.28 (RA1); also elsewhere on the board
N_IO0: RFE.1 (PL2C); also elsewhere on the board
N_IO1: RFE.2 (PL2D)
N_SCK: RFE.42 (PB18A); also elsewhere on the board
N_SCL: RFE.28 (PB4D); also elsewhere on the board
N_SDA: RFE.30 (PB6B); also elsewhere on the board
N_SDI: RFE.29 (PB6A); also elsewhere on the board
N_SDO: RFE.43 (PB18B); also elsewhere on the board
N_SPI_EN: RFE.45 (PB18C); also elsewhere on the board
PB22B_E: RFE.47 (PB18D), U3.23 (RB5)
PROGRAMN_E: RFE.81 (PROGRAMN), U3.15 (RC7)
RFAB_E_V: C14.1, C15.1, C30.1, C31.1, RFE.50 (VCC), RFE.100 (VCC); also elsewhere on the board
SCK_E: RFE.31 (MCLK), U3.3 (RA4)
SDI_E: RFE.49 (SI/SISPI), U3.21 (RB3)
SDO_E: RFE.32 (SO/SPISO), U3.2 (RA3)
SH_NE_IO0: HDR-NE.4, RFE.4 (PL3B)
SH_NE_IO1: HDR-NE.3, RFE.3 (PL3A)
SH_NE_IO2: HDR-NE.6, RFE.8 (PL3D)
SH_NE_IO3: HDR-NE.5, RFE.7 (PL3C)
SH_NE_IO4: HDR-NE.8, RFE.10 (PL4B)
SH_NE_IO5: HDR-NE.7, RFE.9 (PL4A)
SH_NE_IO6: HDR-NE.10, RFE.12 (PL5A)
SH_NE_IO7: HDR-NE.9, RFE.13 (PL5B)
SH_NE_IO8: HDR-NE.12, RFE.16 (PL8A)
SH_NE_IO9: HDR-NE.11, RFE.17 (PL8B)
SH_SE_IO0: HDR-SE.4, RFE.67 (PR4C)
SH_SE_IO1: HDR-SE.3, RFE.66 (PR4D)
SH_SE_IO2: HDR-SE.6, RFE.65 (PR5A)
SH_SE_IO3: HDR-SE.5, RFE.64 (PR5B)
SH_SE_IO4: HDR-SE.8, RFE.63 (PR5C)
SH_SE_IO5: HDR-SE.7, RFE.62 (PR5D)
SH_SE_IO6: HDR-SE.10, RFE.60 (PR8C)
SH_SE_IO7: HDR-SE.9, RFE.59 (PR8D)
SH_SE_IO8: HDR-SE.12, RFE.58 (PR9A)
SH_SE_IO9: HDR-SE.11, RFE.57 (PR9B)
SH_SE_V: HDR-SE.2; also elsewhere on the board
SH_SE_VIO: C16.1, C17.1, C18.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C42.1, HDR-SE.1, R19.1, RFE.5 (VCCIO5), RFE.11 (VCCIO4), RFE.23 (VCCIO3), RFE.26 (VCCIO2), RFE.46 (VCCIO2), RFE.55 (VCCIO1), RFE.73 (VCCIO1), RFE.80 (VCCIO0), RFE.93 (VCCIO0), U3.17 (VDD); also elsewhere on the board
SN_E: RFE.48 (SN), U3.22 (RB4)
S_IO0: RFE.75 (PR2A); also elsewhere on the board
S_IO1: RFE.74 (PR2B)
S_IO2: RFE.71 (PR3A)
S_IO3: RFE.70 (PR3B)
S_IO4: RFE.69 (PR4A)
S_IO5: RFE.68 (PR4B)
S_IO6: RFE.54 (PR9C)
S_IO7: RFE.53 (PR9D)
S_IO8: RFE.52 (PR10C)
S_IO9: RFE.51 (PR10D)
TCK_E: RFE.91 (TCK), U3.10 (RC2)
TDI_E: RFE.94 (TDI), U3.9 (RC1)
TDO_E: RFE.95 (TDO), U3.8 (RC0)
TMS_E: RFE.90 (TMS), U3.11 (RC3)

Notes on the sheet:
AXIOM Beta Main Board
Copyright (C) 2015-2020 H.Poetzl Licensed under CERN OHL v.1.2
Interface Fabric East

Schematic: axiom_beta_main_board_v0.38.sch, sheet 1

Parts:
C43, C44: 10n; 0402-B
C45: 1u; 0402-B
D1: DB2S20500L; MICROMELF-R; FARNELL 2284949
FID1, FID2, FID3, FID4, FID5, FID6, FID7, FID8: FIDUCIAL; FID_ARROW
JP1: PINHD-1X02_2.00-90°-S; 1X02M/90-S
JP2: PINHD-1X02_2.00; 1X02M
JX1, JX2: BERGSTAK-61083F; 61083-FAKE
R9, R12: 10k; 0402-B
R10: 200k; 0402-B
R13, R14: 12R4; 0402-B
SP1: KSSG23J12
T1, T2: NX3008NBKT; SOT416
ZED1: µZ-FCI-NOHOLES-R; µZ-NOHOLES-R

Connections:
BANK13_SE_0: ZED1.200 (_0); also elsewhere on the board
CSO_NE_V: ZED1.7 (FPGA_VBAT); also elsewhere on the board
CSO_SW_V: ZED1.112 (VIN_HDR); also elsewhere on the board
DXP_0_N: ZED1.100 (_N)
DXP_0_P: ZED1.98 (_P)
GND: R12.1, T1.2 (S), T2.2 (S), ZED1.15 (GND), ZED1.16 (GND), ZED1.21 (GND), ZED1.22 (GND), ZED1.27 (GND), ZED1.28 (GND), ZED1.33 (GND), ZED1.34 (GND), ZED1.39 (GND), ZED1.40 (GND), ZED1.45 (GND), ZED1.46 (GND), ZED1.51 (GND), ZED1.52 (GND), ZED1.65 (GND), ZED1.66 (GND), ZED1.71 (GND), ZED1.72 (GND), ZED1.77 (GND), ZED1.85 (GND), ZED1.86 (GND), ZED1.95 (GND), ZED1.96 (GND), ZED1.115 (GND), ZED1.116 (GND), ZED1.121 (GND), ZED1.122 (GND), ZED1.127 (GND), ZED1.128 (GND), ZED1.133 (GND), ZED1.134 (GND), ZED1.139 (GND), ZED1.140 (GND), ZED1.145 (GND), ZED1.146 (GND), ZED1.151 (GND), ZED1.152 (GND), ZED1.165 (GND), ZED1.166 (GND), ZED1.171 (GND), ZED1.172 (GND), ZED1.177 (GND), ZED1.185 (GND), ZED1.186 (GND), ZED1.191 (GND), ZED1.192 (GND); also elsewhere on the board
JX1_SE_0: ZED1.9 (_0); also elsewhere on the board
JX1_SE_1: ZED1.10 (_1)
JX2_SE_0: ZED1.113 (_0)
JX2_SE_1: ZED1.114 (_1)
unnamed: C43.2, JP1.1, T1.3 (D)
unnamed: C44.2, R13.1, T2.3 (D)
unnamed: D1.C, R14.1
unnamed: D1.A, JP2.1, R13.2, SP1.2
unnamed: C43.1, R9.2, R10.2, T1.1 (G)
unnamed: C44.1, C45.1, R12.2, T2.1 (G)
N_IO0: R9.1; also elsewhere on the board
PCIE_I2C_V: ZED1.198 (VCCO_13); also elsewhere on the board
PCIE_N_5V: ZED1.59 (VIN_HDR), ZED1.60 (VIN_HDR); also elsewhere on the board
PCIE_N_V: ZED1.79 (VCCO_34), ZED1.80 (VCCO_34); also elsewhere on the board
PCIE_N_VCCIO: ZED1.78 (VCCO_34); also elsewhere on the board
PCIE_S_5V: ZED1.159 (VIN_HDR), ZED1.160 (VIN_HDR); also elsewhere on the board
PCIE_S_V: ZED1.179 (VCCO_35), ZED1.180 (VCCO_35); also elsewhere on the board
PCIE_S_VCCIO: ZED1.178 (VCCO_35); also elsewhere on the board
PEX_N_V: JP1.2, R10.1, ZED1.57 (VIN_HDR), ZED1.58 (VIN_HDR)
PEX_S_V: JP2.2, R14.2, SP1.1, ZED1.157 (VIN_HDR), ZED1.158 (VIN_HDR)
S_IO0: C45.2; also elsewhere on the board
VP_0_N: ZED1.99 (_N)
VP_0_P: ZED1.97 (_P)

Notes on the sheet:
AXIOM Beta Main Board
Copyright (C) 2014-2020 H.Poetzl Licensed under CERN OHL v.1.2
Power and Control Interface

Notices in the files:
PCBs/axiom_beta_main_board_v0.36_r1.2/axiom_beta_main_board_v0.36_r1.2.brd:
Copyright (C) 2015-2016 Herbert Pötzl
